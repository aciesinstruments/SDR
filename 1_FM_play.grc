options:
  parameters:
    author: Andrea Cantone
    generate_options: qt_gui
    id: FM_chart
    output_language: python
    title: FM broadcast display by Acies Srl
  states: {}

blocks:
- name: LPF_cutoff
  id: variable_qtgui_range
  parameters:
    comment: |-
      Try reducing the bandwidth of
      the received signal and how 
      it impacts of noise
    label: LPF cutoff [kHz]
    start: '10'
    step: '10'
    stop: '160'
    value: '100'
  states: {}
- name: LPF_decimation
  id: variable
  parameters:
    comment: |-
      3. Set the decimation for the LPF that 
          reduces the  sampling rate from SDR 
          out: this gives the SDR samplig rate
    value: '4'
  states: {}
- name: audio_LPF_cutoff
  id: variable_qtgui_range
  parameters:
    comment: |-
      This reduces high frequency noise,
      however it reduced also the audio content:
      a correct RF bandwidth (LFP cutoff) is
      crucial to remove noise
    label: LO frequency [MHz]
    start: '0'
    step: '0.5'
    stop: '20'
    value: '16'
  states: {}
- name: audio_decimation
  id: variable
  parameters:
    comment: |-
      2. Set the audio decimation:  this gives the 
          sampling rate at the output of the FM
          demodulator (receiver)
    value: '10'
  states: {}
- name: fs_audio
  id: variable
  parameters:
    comment: |-
      1. Set the audio
          sampling rate
    value: '48000'
  states: {}
- name: fs_receiver
  id: variable
  parameters:
    value: fs_audio * audio_decimation
  states: {}
- name: fs_sdr
  id: variable
  parameters:
    value: fs_receiver * LPF_decimation
  states: {}
- name: lofreq
  id: variable_qtgui_range
  parameters:
    comment: |-
      Use this to set the frequency 
      of the broadcast station you 
      want to receive
    label: LO frequency [MHz]
    start: '88.1'
    step: '0.2'
    stop: '107.9'
    value: '95.7'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: int(audio_decimation)
    quad_rate: fs_receiver
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: int(48000)
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '200000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int(lofreq * 1e6)
    gain1: '''manual'''
    manual_gain1: '64'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(fs_sdr)
    type: fc32
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: LPF_cutoff * 1e3
    decim: LPF_decimation
    gain: '1'
    samp_rate: fs_sdr
    type: fir_filter_ccf
    width: '20000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: audio_LPF_cutoff * 1e3
    decim: '1'
    gain: '1'
    samp_rate: fs_audio
    type: fir_filter_fff
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: fs_sdr
    fc: int(lofreq*1e6)
    fftsize: '32768'
    legend: 'False'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: fs_receiver
    fc: '0'
    fftsize: '32768'
    legend: 'False'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: '48000'
    fc: '0'
    fftsize: '32768'
    legend: 'False'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: fs_sdr
    fc: '0'
    fftsize: '32768'
    type: complex
  states: {}

connections:
- [analog_wfm_rcv_0, '0', low_pass_filter_0_0, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_0_0, '0', audio_sink_0, '0']
- [low_pass_filter_0_0, '0', qtgui_freq_sink_x_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
